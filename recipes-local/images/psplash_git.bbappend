# Customized form: https://stackoverflow.com/a/47776126

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://miccentericon.png;outsuffix=default"
